<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>bokeh_gui</value></param>
</block>
<block>
<key>variable_bokehgui_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>45</value></param>
<param><key>end</key><value>50</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>throttle</key><value>1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>128000</value></param>
</block>
<block>
<key>variable_bokehgui_range_slider</key>
<param><key>id</key><value>waterfall_range</value></param>
<param><key>value</key><value>(-70, 0)</value></param>
<param><key>end</key><value>0</value></param>
<param><key>label</key><value>Waterfall Color Range</value></param>
<param><key>start</key><value>-150</value></param>
<param><key>step</key><value>1</value></param>
<param><key>throttle</key><value>1</value></param>
<param><key>type</key><value>int_vector</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>4321</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>bokehgui_waterfall_sink_x</key>
<param><key>id</key><value>bokehgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>8096</value></param>
<param><key>grid</key><value>False</value></param>
<param><key>int_max</key><value>waterfall_range[1]</value></param>
<param><key>int_min</key><value>waterfall_range[0]</value></param>
<param><key>label</key><value></value></param>
<param><key>legend</key><value>True</value></param>
<param><key>color</key><value>Inferno</value></param>
<param><key>name</key><value>""</value></param>
<param><key>placement</key><value>(2,0,1,2)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>750</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>xlabel</key><value>Frequency</value></param>
<param><key>xunit</key><value>Hz</value></param>
<param><key>ylabel</key><value>Time</value></param>
<param><key>yunit</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>p_samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128000</value></param>
</block>
<block>
<key>xmlrpc_client</key>
<param><key>id</key><value>xmlrpc_client_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>callback</key><value>set_gain</value></param>
<param><key>port</key><value>8080</value></param>
<param><key>variable</key><value>gain</value></param>
</block>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>bokehgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
