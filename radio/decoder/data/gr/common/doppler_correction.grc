<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>doppler_correction</value></param>
<param><key>category</key><value>RedSat</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>location</value></param>
<param><key>field0</key><value>lat</value></param>
<param><key>field1</key><value>lon</value></param>
<param><key>field2</key><value>elv</value></param>
<param><key>value2</key><value>meta_elv</value></param>
<param><key>value0</key><value>meta_lat</value></param>
<param><key>value1</key><value>meta_lon</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>m_dbg</value></param>
<param><key>value</key><value>dbg</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_elv</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>elv</value></param>
<param><key>section</key><value>position</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_freq</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_gain</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_lat</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>lat</value></param>
<param><key>section</key><value>position</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_lon</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>lon</value></param>
<param><key>section</key><value>position</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_output_file</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>splitext(v_meta_file)[0] + ".raw"</value></param>
<param><key>option</key><value>output_file</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_samp_rate</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>128000</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_time</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>time</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_tle</value></param>
<param><key>config_file</key><value>v_meta_file</value></param>
<param><key>value</key><value></value></param>
<param><key>option</key><value>tle</value></param>
<param><key>section</key><value>tle</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_0</value></param>
<param><key>block_id</key><value>m_dbg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_args</key><value>self.location.lat</value></param>
<param><key>function_name</key><value>print_value</value></param>
<param><key>value</key><value>10</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>v_probe</value></param>
<param><key>block_id</key><value>m_dbg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>function_args</key><value>self.doppler_shift.level()</value></param>
<param><key>function_name</key><value>print_value</value></param>
<param><key>value</key><value>10</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>int(p_doppler_correct&gt;0)</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>-meta_freq-p_offset</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("DopplerUpdate")</value></param>
<param><key>nsamps</key><value>int(meta_samp_rate/p_doppler_correct) if p_doppler_correct &gt; 0 else 0xFFFFFFFFFFFFFFFF</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.intern("Now")</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>meta_samp_rate if p_realtime else int(1e12)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vco_c</key>
<param><key>id</key><value>blocks_vco_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
<param><key>sensitivity</key><value>-2*pi</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>dbg</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph

def print_value(value):
	print(value)</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>doppler_calculator</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import pmt
import ephem
from time import gmtime, strftime
from math import floor

class doppler_calculator(gr.sync_block):
    C = 299792458. # light speed

    def __init__(self, 
        time=0., 
        freq=0., 
        samp_rate=0., 
        tle="", 
        location=None,
        dbg=True):
        gr.sync_block.__init__(
            self,
            name='Doppler calculator',
            in_sig=[np.complex64],
            out_sig=[np.float32]
        )
        self.time = time
        self.samp_rate = samp_rate       
        self.freq = freq        
                
        self.obs = ephem.Observer()        
        if location is not None:
            self.obs.lat = str(location.lat)
            self.obs.lon = str(location.lon)
            self.obs.elevation = float(location.elv)

        tle_data = tle.split(",")
        if len(tle_data) &gt;= 3:
            self.sat = ephem.readtle(tle_data[0], tle_data[1], tle_data[2])
        elif len(tle) &gt; 0:
            raise ValueError("TLE string should have three entries separated by commas")
        else:
            pass
        
        self.current_time = None
        if time != 0.: # avoid exception at design time
            self.last_freq = self.get_doppler_freq_intp(0)
        else:
            self.last_freq = freq

        self.dbg = dbg
        if dbg:
            print "time: ", self.time
            print "freq:", self.freq
            if location is not None:
                print "lat, lon, elv:", location.lat, location.lon, location.elv
            print "obs:", self.obs

    def work(self, input_items, output_items):        
        num_input_items = len(input_items[0])

        nread = self.nitems_read(0)
        tags = self.get_tags_in_range(0, nread, nread+num_input_items)

        output_items[0][:] = self.last_freq
        if len(tags) &gt; 0:
            d_f = None
            for tag in tags:
                if pmt.eqv(tag.key, pmt.intern("DopplerUpdate")):
                    i = tag.offset - nread                
                    d_f = self.get_doppler_freq_intp(tag.offset)
                    output_items[0][i:] = d_f
                    
                    if self.dbg:
                        print(gmtime(self.time + tag.offset/self.samp_rate), d_f)

            self.last_freq = d_f
        
        return num_input_items

    def get_doppler_freq(self, time):
        self.obs.date = strftime('%Y/%m/%d %H:%M:%S', gmtime(time))
        self.sat.compute(self.obs)
        doppler = (self.freq - self.sat.range_velocity * self.freq / self.C)
        return doppler

    # linear interpolation between full seconds
    def get_doppler_freq_intp(self, offset):
        new_time = self.time + float(offset)/float(self.samp_rate)

        if self.current_time is None or floor(new_time) != self.current_time:
            self.current_time = floor(new_time)

            self.current_doppler = self.get_doppler_freq(self.current_time)
            self.next_doppler = self.get_doppler_freq(self.current_time + 1)

        return self.current_doppler + (self.next_doppler - self.current_doppler) * (new_time - self.current_time)

        
</value></param>
<param><key>dbg</key><value>False</value></param>
<param><key>freq</key><value>meta_freq</value></param>
<param><key>location</key><value>location</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
<param><key>time</key><value>meta_time</value></param>
<param><key>tle</key><value>meta_tle</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>doppler_shift</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>epy_module_0</value></param>
<param><key>source_code</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from os.path import splitext</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>p_doppler_correct</value></param>
<param><key>comment</key><value>doppler correction update rate, set to 0 to disable</value></param>
<param><key>label</key><value>Update Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>p_offset</value></param>
<param><key>label</key><value>Freq Offset</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>p_realtime</value></param>
<param><key>label</key><value>Realtime</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>source</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>v_meta_file</value></param>
<param><key>label</key><value>Metafile</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_vco_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>doppler_calculator</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vco_c_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>doppler_calculator</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>doppler_calculator</source_block_id><sink_block_id>doppler_shift</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
