<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>create_waterfall</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename_base</value></param>
<param><key>value</key><value>splitext(filename)[0]</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_samp_rate</value></param>
<param><key>config_file</key><value>filename</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>file_source</key>
<param><key>id</key><value>file_source_0</value></param>
<param><key>p_doppler_correct</key><value>10</value></param>
<param><key>p_offset</key><value>freq_offset</value></param>
<param><key>p_meta_file</key><value>filename</value></param>
<param><key>p_realtime</key><value>False</value></param>
</block>
<block>
<key>file_source</key>
<param><key>id</key><value>file_source_0_0</value></param>
<param><key>p_doppler_correct</key><value>0</value></param>
<param><key>p_offset</key><value>freq_offset</value></param>
<param><key>p_meta_file</key><value>filename</value></param>
<param><key>p_realtime</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>filename</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>""</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>label</key><value>Freq Offset</value></param>
<param><key>short_id</key><value>o</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from os.path import splitext</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>keep</value></param>
<param><key>label</key><value>keep</value></param>
<param><key>short_id</key><value>k</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>range_selector</key>
<param><key>id</key><value>range_selector_0</value></param>
<param><key>keep</key><value>keep</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
<param><key>skip</key><value>skip</value></param>
</block>
<block>
<key>range_selector</key>
<param><key>id</key><value>range_selector_0_0</value></param>
<param><key>keep</key><value>keep</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
<param><key>skip</key><value>skip</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>filename_base + ".nd.wf"</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>15</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>4096</value></param>
<param><key>filename</key><value>filename_base + ".d.wf"</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>15</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>skip</value></param>
<param><key>label</key><value>skip</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<connection><source_block_id>file_source_0</source_block_id><sink_block_id>range_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>file_source_0_0</source_block_id><sink_block_id>range_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>range_selector_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>range_selector_0_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
