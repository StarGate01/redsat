<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receiver</value></param>
<param><key>author</key><value>Christoph Honal</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>REDSAT receiver</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth_rtlsdr</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_real</value></param>
<param><key>value</key><value>meta_freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100000000</value></param>
<param><key>step</key><value>5000</value></param>
<param><key>stop</key><value>200000000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>meta_gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>meta_samp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rtlsdr</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>unix_now</value></param>
<param><key>value</key><value>str(calendar.timegm(time.gmtime()))</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_1</value></param>
<param><key>input_index</key><value>meta_rec_udp</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>meta_output_file</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>ipaddr</key><value>meta_rec_udp_host</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>meta_rec_udp_port</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0_0</value></param>
<param><key>import</key><value>import calendar</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_dev</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl_tcp=host.docker.internal:1234</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_freq</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>145950000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_output_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/app/input/test.raw</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rec_udp</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rec_udp_host</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>127.0.0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rec_udp_port</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>7575</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_samp</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128000</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>bandwidth_rtlsdr</value></param>
<param><key>freq0</key><value>freq_real</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>meta_dev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rtlsdr</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth_rtlsdr</value></param>
<param><key>fc</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_rtlsdr/samp_rate)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_1</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blks2_selector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
