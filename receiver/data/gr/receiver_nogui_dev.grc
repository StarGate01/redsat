<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receiver_nogui_dev</value></param>
<param><key>author</key><value>Christoph Honal, Alexander Ulanowski</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>REDSAT receiver (device)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth_rtlsdr</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_freq</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>145950000</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_gain</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>38</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_output_file</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>splitext(config_file)[0] + ".raw"</value></param>
<param><key>option</key><value>output_file</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_samp_rate</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>128000</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_time</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>time</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>start_time</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>meta_samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_time</value></param>
<param><key>value</key><value>time.time()</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_meta_sink</key>
<param><key>id</key><value>blocks_file_meta_sink_0</value></param>
<param><key>detached</key><value>False</value></param>
<param><key>extra_dict</key><value>""</value></param>
<param><key>file</key><value>meta_output_file</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>max_seg_size</key><value>1000000</value></param>
<param><key>rel_rate</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("time")</value></param>
<param><key>nsamps</key><value>meta_samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.intern(str(time.time()))</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./default.ini</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from os.path import splitext</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_dev</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>rtl=0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_samp_rate_dev</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>bandwidth_rtlsdr</value></param>
<param><key>freq0</key><value>meta_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>meta_gain</value></param>
<param><key>args</key><value>meta_dev</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>meta_samp_rate_dev</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>int(meta_samp_rate_dev/samp_rate)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>filename</key><value>splitext(config_file)[0] + ".wf"</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>15</value></param>
<param><key>samp_rate</key><value>meta_samp_rate</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>time_updater</value></param>
<param><key>callback</key><value>lambda t: self.set_start_time(t)</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import time

# lambda t: self.set_start_time(t)

class blk(gr.sync_block):
    def __init__(self, callback=None):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='First packet time callback',
            in_sig=[np.complex64],
            out_sig=None
        )
        
        self.time = None
        self.callback = callback

    def work(self, input_items, output_items):        
        if self.time is None:
            self.time = time.time()
            if self.callback is not None:
                print('calling callback to set time:', self.time)
                self.callback(self.time)
        return len(input_items)</value></param>
<param><key>comment</key><value>This packets waits for the first packet to arrive on the stream and calls the callback with the arrival time.</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_file_meta_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>time_updater</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
