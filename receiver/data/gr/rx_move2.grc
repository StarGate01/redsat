<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_move2</value></param>
<param><key>author</key><value>alu</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>MOVE II</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_freq</value></param>
<param><key>value</key><value>freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>doppler_shift</value></param>
<param><key>value</key><value>doppler_freq-freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filename</value></param>
<param><key>value</key><value>"iq_{0}_f{1}_g{2}".format(time.strftime("%Y-%m-%d_%H-%M-%S"), int(freq), gain)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>128000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rtlsdr</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_1</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>doppler_shift</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks2_tcp_sink_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>filename + ".raw"</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>filename + ".raw_dpl"</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_streams_to_vector</key>
<param><key>id</key><value>blocks_streams_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>freq</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>145.95e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>38</value></param>
</block>
<block>
<key>gpredict_doppler</key>
<param><key>id</key><value>gpredict_doppler_0</value></param>
<param><key>gpredict_host</key><value>0.0.0.0</value></param>
<param><key>gpredict_port</key><value>4532</value></param>
<param><key>target</key><value>doppler_freq</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate_rtlsdr</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(samp_rate_rtlsdr/samp_rate)</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>satnogs_waterfall_sink</key>
<param><key>id</key><value>satnogs_waterfall_sink_0</value></param>
<param><key>center_freq</key><value>0.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>filename</key><value>filename + ".wf"</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>pps</key><value>5</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_1</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blks2_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>satnogs_waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_streams_to_vector_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_streams_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
