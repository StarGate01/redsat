<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>receiver_gui_audio</value></param>
<param><key>author</key><value>Christoph Honal, Alexander Ulanowski</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>REDSAT receiver (audio)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bandwidth_rtlsdr</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_freq</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>145950000</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_gain</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>38</value></param>
<param><key>option</key><value>gain</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_output_file</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>splitext(config_file)[0] + ".raw"</value></param>
<param><key>option</key><value>output_file</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_samp_rate</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>128000</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>meta_time</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>time</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>start_time</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>meta_samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_rtlsdr</value></param>
<param><key>value</key><value>1536000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>start_time</value></param>
<param><key>value</key><value>time.time()</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>device_name</key><value>meta_rec_audio_dev</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>meta_output_file</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>./default.ini</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import sys</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from os.path import splitext</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1_0</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>meta_rec_audio_dev</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>pulse</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>bandwidth_rtlsdr</value></param>
<param><key>fc</key><value>samp_rate</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>50</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>time_updater</value></param>
<param><key>callback</key><value>lambda t: self.set_start_time(t)</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr
import time

# lambda t: self.set_start_time(t)

class blk(gr.sync_block):
    def __init__(self, callback=None):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='First packet probe',
            in_sig=[np.complex64],
            out_sig=[]
        )
        
        self.time = None
        self.callback = callback

        print(self.callback)
        

    def work(self, input_items, output_items):        
        if self.time is None:
            self.time = time.time()
            if self.callback is not None:
                print('calling callback to set time:', self.time)
                self.callback(self.time)
        return 0</value></param>
<param><key>comment</key><value>This packets waits for the first packet to arrive on the stream and calls the callback with the arrival time.</value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>time_updater</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
